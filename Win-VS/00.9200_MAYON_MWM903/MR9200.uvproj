# Keil uVision project MR9200.uvproj, settings and files
target USB_Boot (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: MR9300
  AfterMake: fromelf --bin --output=exe\pa9001.bin out\obj\MR9300.axf
  AfterMake: exe\1018CopyToUSB93_mdk.bat
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STANDALONE
  c include: .\inc;.\board\inc;.\ucos_ii\inc;.\..\inc;.\ciu\inc;.\rfiu\inc;.\inc\mars_controller;.\mars_timer\inc;.\inc\os;.\mars_dma\inc;.\mars_int\inc;.\mars_system\inc;.\spi\inc;.\isp\inc;.\mov\inc;.\avi\inc;.\asf\inc;.\mp4\inc;.\sys\inc;.\dpof\inc;.\dcf\inc;.\hiu\inc;.\ui\inc;.\adc\inc;.\iis\inc;.\smc\inc;.\LwIP_2.0\include;.\LwIP_2.0\include\tutk_P2P;.\LwIP_2.0\include\netif;.\rtc\inc;.\gpio\inc;.\timer\inc;.\idu\inc;.\isu\inc;.\ipu\inc;.\hdmi\inc;.\ramdisk\inc;.\siu\inc;.\VideoCodec\mpeg4\inc;.\VideoCodec\h264\inc;.\VideoCodec\common\inc;.\jpeg\inc;.\i2c\inc;.\usb\inc;.\sdc\inc;.\uart\inc;.\encrypt\inc;.\shell\inc;.\fs\inc;.\debug\inc;.\main\inc
  asm define: USE_SCATTER_SYMS
  asm include: .\inc
  scatter file: .\board\scatter.txt
  link misc: --entry=START_0
--keep=init*.o
  group board
    ./board/src/: retarget.c initshadow.c general.c submain.c initstmem.s initsysctrl.s embed_uish.s init.s vectors.s initmmu.s initcache.s ttb.s initsdram.s
    ./lib/: tutk_iotc_ARM7.lib
  group SDK
    ./SDK/src/: SDK_record.c SDK_playback.c
  group ciu
    ./ciu/src/: MotionDetect_HW.c ciu.c
  group RFIU
    ./rfiu/src/: HomeRF_project.c HomeRF.c RFNONE.c AMIC7196.c WrapRF.c AMIC7130.c MV400.c rfiu.c
  group mars_timer
    ./mars_timer/src/: mars_timer.c
  group mars_dma
    ./mars_dma/src/: mars_dmareqfunc.c mars_dma.c
  group mars_int
    ./mars_int/src/: mars_int.c
  group mars_system
    ./mars_system/src/: mars_system.c
  group spi
    ./spi/src/: Spiapi.c spi_ESMT.c spi_WBD_EON.c
  group isp
    ./isp/src/: isp.c
  group mov
    ./mov/src/: mov.c
  group avi
    ./avi/src/: avi.c
  group asf
    ./asf/src/: MultiChannelASF.c asf.c
  group mp4
    ./mp4/src/: mp4.c
  group sys
    ./sys/src/: sys.c sys_project.c sys_api.c
  group dpof
    ./dpof/src/: dpof.c
  group dcf
    ./dcf/src/: exif.c dcffs.c dcf.c
  group hiu
    ./hiu/src/: hiu.c
  group ui
    ./ui/src/: ui_setfile_project.c ui.c ui_node_project.c ui_flow_project.c ui_graph.c ui_graph_project.c ui_osd.c ui_osd_project.c ui_cmd_project.c ui_act_project.c
  group adc
    ./adc/src/: adc.c adc_project.c
  group iis
    ./iis/src/: MultiChannelIIS.c ima_adpcm.c ms_adpcm.c iis.c
  group smc
    ./smc/src/: SmcECCSW.c smcmap_Adv.c smcfs_Normal.c smcfs_Adv.c smc_9002_Adv.c smc_9002_Normal.c smcusb.c smcwc.c smcmap_Normal.c smc_9001_Normal.c
  group LwIP_2.0
    ./LwIP_2.0/rtsp/: sdp.c
    ./LwIP_2.0/netif/: FTMAC110.C ethernetif.c ethernet.c
    ./LwIP_2.0/: LwIPEntry.c
    ./LwIP_2.0/core/ipv4/: dhcp.c etharp.c icmp.c ip4_addr.c autoip.c ip4.c ip4_frag.c
    ./LwIP_2.0/core/: mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c sys_arch.c ip.c rtos.c dns.c def.c timeouts.c inet_chksum.c init.c
    ./LwIP_2.0/api/: tcpip.c api_lib.c api_msg.c err.c sockets.c netdb.c netbuf.c
    ./LwIP_2.0/mars/: porting.c
    ./LwIP_2.0/tutk_P2P/: tcp_client_api.c tutk_iotc_sample.c tutk_av_sample.c P2P_server.c P2P_cmd_project.c TMR.C
  group rtc
    ./rtc/src/: rtc.c
  group gpio
    ./gpio/src/: ir_ppm.c gpio.c gpio_project.c
  group timer
    ./timer/src/: timer.c timer_project.c
  group idu
    ./idu/src/: gfu.c idu.c tsc2046_spi.c
  group isu
    ./isu/src/: ascii_font_16x22x95_Commax_2bit.c ascii_font_8x16x95_2bit.c ascii_font_20x20x95_double_field_2bit_DR900.c ascii_font_20x20x95_double_field_2bit.c ascii_font_20x20x95_2bit.c ascii_font_12x12x95_2bit.c ascii_font_32x40x95_2bit.c ascii_font_32x40x95_1bit.c ascii_font_20x20x95_DR900.c ascii_font_12x12x95.c ascii_font_20x36x95.c ascii_font_20x20x95_25.c ascii_font_32x48x95.c ascii_font_32x40x95.c ascii_font_20x20x95_2.c ascii_font_20x20x95_1.c ascii_font_20x20x95_0.c ascii_font_20x20x95.c isu.c ascii_font_64x40x95_2bit_with_antenna.c
  group ipu
    ./ipu/src/: CalAWBGain.c ipu.c
  group hdmi
    ./hdmi/src/: EP952api.c EP952Controller.c EP952SettingsData.c IT66121_Utility.c IT66121_csc.c IT66121_hdmitx_drv.c IT66121_hdmitx_input.c IT66121_hdmitx_sys.c IT66121_IO.c IT66121_hdmitx_hdcp.c IT66121_sha1.c
  group ramdisk
    ./ramdisk/src/: ramdisk.c
  group siu
    ./siu/src/: siu_NONE.c siu_PO2210K_YUV.c siu_NT99340_YUV.c siu_NT99230_YUV.c siu_PO3100K_YUV.c siu_HM5065_YUV.c siu_NT99141_YUV.c siu_HM1375_YUV.c siu_MT9M131_YUV.c siu_OV2643_YUV.c siu_OV7740_RAW.c MotionDetect_API.c siu_MI1320_Raw.c siu_OV7740_YUV.c siu_OV7725_YUV.c siu_MI1320.c siu_MotionDetect.c siu_CCIR656.c siu_OV7725.c AWB.c siu_AF_ZOOM.c siumem.c siu_5M.c siu_2M.c compdefectpix.c siu_XC7021_ISP.c siu_XC7021_GC2023.c siu_ZN220_YUV.c
  group mpeg4
    ./VideoCodec/./mpeg4/src/: MultiChannelMPEG4.c Mp4RateControl.c mpeg4.c
  group H264
    ./VideoCodec/./h264/src/: MultiChannelH264.c header.c nalu.c nal.c parset.c H264.c H264RateControl.c
    ./VideoCodec/./h264/src//: vlc.c
  group VideoCodecCommon
    ./VideoCodec/./common/src/: VideoCodec_common.c
  group jpeg
    ./jpeg/src/: jpeg.c
  group i2c
    ./i2c/src/: i2c.c
  group usb
    ./usb/src/: usb-hub.c usb_storage.c usb-transfer.c ehci-hcd.c ehci-a1016a.c usb_Hostintevt.c usb_Host.c usb_Device_msc.c usb_Device.c usbmsccb.c usbapiex.c usbmscfs.c usbclass.c usbdesc.c usbvc.c usbmsc.c usbintevt.c usbdev.c usbcb.c usbapievt.c usb.c usb_Host_EHCI.c
  group sdc
    ./sdc/src/: sdcusb.c sdcfs.c mmc.c sdc.c sdcerr.c
  group uart
    ./uart/src/: uart.c
  group encrypt
    ./encrypt/src/: des.c encrypt.c
  group fs
    ./fs/src/: fs_info.c api_in.c api_misc.c api_out.c api_dir.c clibmisc.c storage.c fat_out.c fat_dir.c fat_in.c fat_ioct.c fat_misc.c fat_open.c fat_data.c lb_misc.c fs_x_ucos_ii.c
  group debug
    ./debug/src/: debug.c
  group main
    ./main/src/: GlobalVariable.c core_util.c core_state.c core_portme.c core_matrix.c core_main.c core_list_join.c mcpu.c mmu.c ClockSwitch.c MemoryPool.c main.c main_task_project.c
  group ucos_ii
    ./ucos_ii/src/: OS_CORE_1.C OS_CPU_C.C UCOS_II.C OS_CPU_A.S
  group dummy
    ./dummy/src/: dummy.c
